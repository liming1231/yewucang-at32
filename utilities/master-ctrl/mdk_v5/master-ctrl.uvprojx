# Keil uVision project master-ctrl.uvprojx, settings and files
target master-ctrl (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F415RCT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.0.7
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: master-ctrl +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F415RCT7,USE_STDPERIPH_DRIVER,AT_START_F415_V1
  c include: ..\inc;..\..\..\libraries\drivers\inc;..\..\..\project\at32f415_board;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\cmsis\cm4\core_support;..\..\..\middlewares\freertos\source\include;..\..\..\middlewares\freertos\source\portable\memmang;..\..\..\middlewares\freertos\source\portable\rvds\ARM_CM3
  memory RVCT4: ROM 0x8004000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: at32f415_clock.c at32f415_int.c main.c ax_uart.c ax_can.c ax_spi.c ax_ws2812.c ax_common.c ax_flash.c ax_iap.c
  group bsp
    ../../../project/at32f415_board/: at32f415_board.c
  group firmware
    ../../../libraries/drivers/src/: at32f415_adc.c at32f415_can.c at32f415_cmp.c at32f415_crc.c at32f415_crm.c at32f415_debug.c at32f415_dma.c at32f415_ertc.c at32f415_exint.c at32f415_flash.c at32f415_gpio.c at32f415_i2c.c at32f415_misc.c at32f415_pwc.c at32f415_sdio.c at32f415_spi.c at32f415_tmr.c at32f415_usart.c at32f415_usb.c at32f415_wdt.c at32f415_wwdt.c
  group cmsis
    ../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f415.s
  group freertos
    ../../../libraries/cmsis/cm4/device_support/: system_at32f415.c
    ../../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../middlewares/freertos/source/portable/memmang/: heap_4.c
    ../../../middlewares/freertos/source/portable/rvds/ARM_CM3/: port.c
  group readme
    ../: readme.txt
